# Keil uVision project Project_NRF51.uvprojx, settings and files
target NRF51422 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.3.2
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: NRF51822 +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __CC_ARM, NRF51
  c include: ..\;..\Libraries\CMSIS;..\Libraries\nRF_Components\nRF_Drivers;..\Program
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../Libraries/CMSIS/: arm_startup_nrf51.s system_nrf51.c
  group Library
    ../Program/: nrf51_conf.h
  group Driver
    ../Program/drivers/: nrf51_clock.c nrf51_delay.c
  group Program
    ../Program/: experiment_nrf51.c experiment_nrf51_it.c
